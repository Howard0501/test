# Keil uVision project 867A_Normal.uvprojx, settings and files
target Debug (5060020::V5.06 (build 20)::ARMCC)
  device: CMSDK_CM4 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: 867A_Normal +hex
  c flags: Optim=1 uC99=1
  c define: EM32F867A CORTEX_M4 USE_PRINT ITERATIONS=200 MSC_CLOCK EXPECTED_SYST
  c misc: -Ono_inline --no_inline --no_multifile -Oloopref
  c include: ..\software\cmsis\CMSIS\Include;..\software\cmsis\Device\ARM\CMSDK_CM4\Include;..\software\common\retarget
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  group Startup
    ../software/cmsis/Device/ARM/CMSDK_CM4/Source/ARM/: startup_CMSDK_CM4.s
  group Application
    ./: gpio.c main.c spi.c dma.c retarget.c system.c usb.c usb_app.c uart.c pwm.c i2c.c AES256.C rdpd.c
  group System
    ../software/cmsis/Device/ARM/CMSDK_CM4/Source/: system_CMSDK_CM4.c
  group User
    ./: user_FP1.c user_IFCOM.c
software components: CMSIS:CORE 5.0.0
